# Keil uVision project FreeModbus_Slave&Master+RTT+STM32.uvproj, settings and files
target STM32F103ZET6_FLASH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BX_GeneralProgram
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.0.0\include;..\RT-Thread-1.0.0\libcpu\arm\stm32
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../APP/src/: app.c app_task.c stm32f10x_it.c cpuusage.c
    ../APP/inc/: delay_conf.h stm32f10x_conf.h rtconfig.h
  group BSP
    ../BSP/src/: bsp.c
    ../RT-Thread-1.1.1/libcpu/arm/common/: backtrace.c showmem.c
    ../RT-Thread-1.1.1/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group StdPeriph_Driver
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libaries/CMSIS_MDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libaries/CMSIS_MDK/CM3/CoreSupport/: core_cm3.c
    ../Libaries/CMSIS_MDK/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RT-Thread Kernel
    ../RT-Thread-1.1.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group FreeModbusSlave
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/port/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
  group FreeModbusMaster
    ../FreeModbus/modbus/: mb_m.c
    ../FreeModbus/modbus/rtu/: mbrtu_m.c
    ../FreeModbus/port/: portevent_m.c portserial_m.c porttimer_m.c
    ../FreeModbus/modbus/functions/: mbfuncholding_m.c mbfunccoils_m.c mbfuncinput_m.c mbfuncdisc_m.c
  group Storage
    ../APP/src/: 24cxx.c delay.c myiic.c w25x16.c buffer_ring.c
  group LDS_protocol
    ../APP/src/: LDS_485.C lds_process_cmd.c
target STM32F103RCT6_FLASH (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeModbus_Slaver&Master+RTT+STM32 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libaries\CMSIS_MDK\CM3\CoreSupport;..\Libaries\CMSIS_MDK\CM3\DeviceSupport\ST\STM32F10x;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\Libaries\USB-FS-Device_Driver\inc;..\BSP\inc;..\APP\inc;..\RT-Thread-1.1.1\include;..\RT-Thread-1.1.1\libcpu\arm\stm32;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
