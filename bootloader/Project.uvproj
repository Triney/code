# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project
  AfterMake: fromelf.exe --bin -o./output/Project.bin ./Obj/Project.axf
  AfterMake: fromelf.exe --i32 -o./output/Project.hex ./Obj/Project.axf
  c flags: OneElfS=1
  c include: .\SOFTWARE\APP;.\SOFTWARE\BSP;.\SOFTWARE\Driver;.\SOFTWARE\FWLib\INC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./SOFTWARE/APP/: main.c common.c download.c ymodem.c delay.c LDS_485.C myiic.c w25x16.c
  group BSP
    ./SOFTWARE/BSP/: bsp.c BspTime2.c BspTime3.c BspUsart1.c
  group FWLIB
    ./SOFTWARE/FWLib/: stm32f10x_vector.s
    ./SOFTWARE/FWLib/LIB/: cortexm3_macro.s stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_it.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group DOC
    ./Doc/: note.txt
